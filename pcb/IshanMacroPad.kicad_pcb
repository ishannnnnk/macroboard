# Repository ishannnnnk/macroboard

File README.md:

6 key macropad

schematic:

pcb:

CAD:

What is this
Basically I wanted a small macropad for my most used keybinds/websites (copy, paste, chatgpt, google docs, alt+tab, win+tab) lol

Runs on a Seeed XIAO RP2040 with KMK firmware (CircuitPython-based). Super easy to reprogram without reflashing.

Hardware
MCU: Seeed XIAO RP2040
Switches: 6x Cherry MX compatible switches
the PCB is designed in KiCad

BOM
6x Cherry MX Switches 1x XIAO RP2040 4x Blank DSA Keycaps 4x M3x16 Bolts 4x M3 Heatset Inserts ~50-100g PLA

## KiCad design pcb/IshanMacroPad.kicad_pcb

Parts:
SW1, SW2, SW3, SW4, SW5, SW6: SW_Push; SW_Cherry_MX_1.00u_PCB
U1: XIAO-RP2040-DIP

Connections:
+5V: U1.14 (VBUS)
GND: SW1.1, SW2.1, SW3.1, SW4.1, SW5.1, SW6.1, U1.13 (GND)
unnamed: SW5.2, U1.7 (GPIO0/TX)
unnamed: SW1.2, U1.8 (GPIO1/RX)
unnamed: SW2.2, U1.9 (GPIO2/SCK)
unnamed: SW4.2, U1.11 (GPIO3/MOSI)
unnamed: SW3.2, U1.10 (GPIO4/MISO)
unnamed: SW6.2, U1.6 (GPIO7/SCL)

Board: 2 copper layers, 42.9 x 82.7 mm, 7 parts (0 on the bottom side), 7 nets.
